# Keil uVision project GD32L235R_EVAL.uvprojx, settings and files
target GD32L235R_EVAL (6130001::V6.13.1::.\ARMCLANG)
  device: GD32L235RB GigaDevice
  pack: GigaDevice.GD32L23x_DFP.1.1.6
  cpu: IRAM(0x20000000,0x0006000) IROM(0x08000000,0x0020000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32L235
  c include: ..\..\..\..\GD32L23x_Firmware_Library\CMSIS\GD\GD32L23x\Include;..\..\..\..\GD32L23x_Firmware_Library\GD32L23x_standard_peripheral\Include;..\..\..\Utilities;..\inc;..\..\..\..\GD32L23x_Firmware_Library\GD32L23x_usbd_library\usbd\Include;..\..\..\..\GD32L23x_Firmware_Library\GD32L23x_usbd_library\device\Include;..\..\..\..\GD32L23x_Firmware_Library\GD32L23x_usbd_library\class\device\hid\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Application
    ../src/: main.c gd32l23x_it.c gd32l23x_usbd_hw.c hid_keyboard_itf.c
  group CMSIS
    ../src/: system_gd32l23x.c
  group GD32L23x_Peripherals
    ../../../../GD32L23x_Firmware_Library/GD32L23x_standard_peripheral/Source/: gd32l23x_dma.c gd32l23x_exti.c gd32l23x_fmc.c gd32l23x_gpio.c gd32l23x_misc.c gd32l23x_pmu.c gd32l23x_rcu.c gd32l23x_syscfg.c gd32l23x_timer.c gd32l23x_usart.c gd32l23x_ctc.c
  group GD32L23x_EVAL
    ../../../Utilities/: gd32l235r_eval.c
  group USBD_Drivers
    ../../../../GD32L23x_Firmware_Library/GD32L23x_usbd_library/usbd/Source/: usbd_lld_core.c usbd_lld_int.c
  group USBD_Device
    ../../../../GD32L23x_Firmware_Library/GD32L23x_usbd_library/device/Source/: usbd_core.c usbd_enum.c usbd_pwr.c usbd_transc.c
  group USBD_Class
    ../../../../GD32L23x_Firmware_Library/GD32L23x_usbd_library/class/device/hid/Source/: standard_hid_core.c
  group Startup
    ../../../../GD32L23x_Firmware_Library/CMSIS/GD/GD32L23x/Source/ARM/: startup_gd32l235.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.3.0
